options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: headless_usrp_filterbank
    output_language: python
  states: {}

blocks:
- name: custom_window
  id: variable
  parameters:
    value: sinc*np.hamming(4*vec_length)
  states: {state: disabled}
- name: giantout_bin
  id: variable
  parameters:
    value: giant_prefix + timenow + ".bin"
  states: {state: disabled}
- name: integration_time
  id: variable
  parameters:
    value: '10'
  states: {}
- name: recfile
  id: variable
  parameters:
    value: prefix + timenow + "_Drift.h5"
  states: {state: disabled}
- name: sinc
  id: variable
  parameters:
    value: np.sinc(sinc_sample_locations/np.pi)
  states: {state: disabled}
- name: sinc_sample_locations
  id: variable
  parameters:
    value: np.arange(-np.pi*4/2.0, np.pi*4/2.0, np.pi/vec_length)
  states: {state: disabled}
- name: timeUTC
  id: variable
  parameters:
    value: datetime.utcnow()
  states: {state: disabled}
- name: timenow
  id: variable
  parameters:
    value: datetime.utcnow().strftime("%Y-%m-%d_%H.%M.%S")
  states: {state: disabled}
- name: blocks_complex_to_real_0_0
  id: blocks_complex_to_real
  parameters:
    vlen: vec_length
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: test.bin
    type: float
    vlen: vec_length
  states: {}
- name: blocks_integrate_xx_0_0
  id: blocks_integrate_xx
  parameters:
    decim: int(fast_integration*samp_rate/vec_length)
    type: float
    vlen: vec_length
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: vec_length
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_length
    type: complex
  states: {}
- name: decimation_factor
  id: parameter
  parameters:
    type: intx
    value: '4'
  states: {state: disabled}
- name: fast_integration
  id: parameter
  parameters:
    type: eng_float
    value: '0.0005'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: vec_length
    forward: 'True'
    nthreads: '4'
    shift: 'True'
    type: complex
    window: window.rectangular(vec_length)
  states: {}
- name: freq
  id: parameter
  parameters:
    type: eng_float
    value: 1.4205e9
  states: {}
- name: giant_prefix
  id: parameter
  parameters:
    type: str
    value: '"/home/dspradio/giantPulses/"'
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: from datetime import datetime
  states: {state: disabled}
- name: import_0_0
  id: import
  parameters:
    imports: import numpy as np
  states: {state: disabled}
- name: prefix
  id: parameter
  parameters:
    type: str
    value: '"/home/dspradio/grc_data/"'
  states: {state: disabled}
- name: samp_rate
  id: parameter
  parameters:
    type: eng_float
    value: 25e6
  states: {}
- name: uhd_usrp_source_1
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    center_freq0: freq
    clock_rate: '0.0'
    dc_offs_enb0: 'True'
    dev_args: '""'
    gain0: '35'
    iq_imbal_enb0: 'True'
    maxoutbuf: '16384'
    minoutbuf: '8192'
    otw: sc8
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: vec_length
  id: parameter
  parameters:
    type: intx
    value: '256'
  states: {}

connections:
- [blocks_complex_to_real_0_0, '0', blocks_integrate_xx_0_0, '0']
- [blocks_integrate_xx_0_0, '0', blocks_file_sink_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_complex_to_real_0_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [fft_vxx_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [fft_vxx_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [uhd_usrp_source_1, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
