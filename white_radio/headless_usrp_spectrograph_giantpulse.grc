options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: headless_usrp_giantpulse
    output_language: python
  states: {}

blocks:
- name: custom_window
  id: variable
  parameters:
    value: sinc*np.hamming(4*vec_length)
  states: {}
- name: giantout_bin
  id: variable
  parameters:
    value: giant_prefix + timenow + ".bin"
  states: {}
- name: integration_time
  id: variable
  parameters:
    value: '10'
  states: {}
- name: recfile
  id: variable
  parameters:
    value: prefix + timenow + "_Drift.h5"
  states: {}
- name: sinc
  id: variable
  parameters:
    value: np.sinc(sinc_sample_locations/np.pi)
  states: {}
- name: sinc_sample_locations
  id: variable
  parameters:
    value: np.arange(-np.pi*4/2.0, np.pi*4/2.0, np.pi/vec_length)
  states: {}
- name: timeUTC
  id: variable
  parameters:
    value: datetime.utcnow()
  states: {}
- name: timenow
  id: variable
  parameters:
    value: datetime.utcnow().strftime("%Y-%m-%d_%H.%M.%S")
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '4'
    type: complex
    vlen: vec_length
  states: {}
- name: blocks_complex_to_real_0_0
  id: blocks_complex_to_real
  parameters:
    vlen: vec_length
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: vec_length
    type: complex
  states: {}
- name: blocks_delay_0_0_0
  id: blocks_delay
  parameters:
    delay: 2*vec_length
    type: complex
  states: {}
- name: blocks_delay_0_0_0_0
  id: blocks_delay
  parameters:
    delay: 3*vec_length
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: giantout_bin
    type: float
    vlen: vec_length//decimation_factor
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: int((integration_time)*samp_rate/vec_length)//int(fast_integration*samp_rate/vec_length)
    type: float
    vlen: vec_length
  states: {}
- name: blocks_integrate_xx_0_0
  id: blocks_integrate_xx
  parameters:
    decim: int(fast_integration*samp_rate/vec_length)
    type: float
    vlen: vec_length
  states: {}
- name: blocks_integrate_xx_1
  id: blocks_integrate_xx
  parameters:
    decim: decimation_factor
    type: float
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: vec_length
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: custom_window[0:vec_length]
    type: complex
    vlen: vec_length
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: custom_window[vec_length:2*vec_length]
    type: complex
    vlen: vec_length
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: custom_window[2*vec_length:3*vec_length]
    type: complex
    vlen: vec_length
  states: {}
- name: blocks_multiply_const_vxx_0_2
  id: blocks_multiply_const_vxx
  parameters:
    const: custom_window[-vec_length:]
    type: complex
    vlen: vec_length
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_length
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_length
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_1
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_length
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_2
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_length
    type: complex
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_length//decimation_factor
    type: float
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: vec_length
    type: float
  states: {}
- name: decimation_factor
  id: parameter
  parameters:
    type: intx
    value: '4'
  states: {}
- name: fast_integration
  id: parameter
  parameters:
    type: eng_float
    value: '0.0005'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: vec_length
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.rectangular(vec_length)
  states: {}
- name: freq
  id: parameter
  parameters:
    type: eng_float
    value: 1.4205e9
  states: {}
- name: giant_prefix
  id: parameter
  parameters:
    value: '"/home/dspradio/giantPulses/"'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from datetime import datetime
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: prefix
  id: parameter
  parameters:
    value: '"/home/dspradio/grc_data/"'
  states: {}
- name: radio_astro_hdf5_sink_1
  id: radio_astro_hdf5_sink
  parameters:
    fname: recfile
    freq_start: freq - samp_rate/2
    freq_step: samp_rate/vec_length
    intype: float
    n_inputs: '1'
    notes: amber:39.659,-79.872.  horn3b, lna V3 mod, thin, 5.2/5.2cm probe, 20,12,10
    pointing: A180E55
    save_toggle: '"True"'
    vec_length: vec_length
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    type: eng_float
    value: 2.5e6
  states: {}
- name: uhd_usrp_source_1
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    center_freq0: freq
    clock_rate: '0.0'
    dc_offs_enb0: 'True'
    dev_args: '""'
    gain0: '35'
    iq_imbal_enb0: 'True'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: vec_length
  id: parameter
  parameters:
    type: intx
    value: '1024'
  states: {}

connections:
- [blocks_add_xx_0, '0', fft_vxx_0, '0']
- [blocks_complex_to_real_0_0, '0', blocks_integrate_xx_0_0, '0']
- [blocks_delay_0_0, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_delay_0_0_0, '0', blocks_stream_to_vector_0_2, '0']
- [blocks_delay_0_0_0_0, '0', blocks_stream_to_vector_0_1, '0']
- [blocks_integrate_xx_0, '0', radio_astro_hdf5_sink_1, '0']
- [blocks_integrate_xx_0_0, '0', blocks_integrate_xx_0, '0']
- [blocks_integrate_xx_0_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_integrate_xx_1, '0', blocks_stream_to_vector_1, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_complex_to_real_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '3']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_0, '2']
- [blocks_multiply_const_vxx_0_1, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_0_2, '0', blocks_add_xx_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_multiply_const_vxx_0_2, '0']
- [blocks_stream_to_vector_0_0, '0', blocks_multiply_const_vxx_0_1, '0']
- [blocks_stream_to_vector_0_1, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_stream_to_vector_0_2, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_stream_to_vector_1, '0', blocks_file_sink_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_integrate_xx_1, '0']
- [fft_vxx_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [fft_vxx_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [uhd_usrp_source_1, '0', blocks_delay_0_0, '0']
- [uhd_usrp_source_1, '0', blocks_delay_0_0_0, '0']
- [uhd_usrp_source_1, '0', blocks_delay_0_0_0_0, '0']
- [uhd_usrp_source_1, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
